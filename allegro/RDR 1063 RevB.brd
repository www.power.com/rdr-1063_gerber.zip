# Allegro board RDR 1063 RevB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N13076903: length 3.6
  BOTTOM w0.762: C14.1 89.31,17.94 89.31,17.59 U2.3
N13077057: length 2.7
  TOP w0.762: C16.1 88.7,7.65 87.67,8.67 R13.2
N13077159: length 6.2
  BOTTOM w0.508: R89.2 86.68,27.5 86,28.18 85.21,28.18 84.96,28.42 Q8.1 86.37,29.1 86.38,29.11 VR10.1
N13081652: length 8.3
  BOTTOM w0.254: U3.13 69.62,57.35 69.65,57.38
  BOTTOM w0.508: 70.95,61.28 C19.1 ; 70.95,61.28 69.57,61.28 68.9,60.6 68.9,58.13 69.65,57.38 ; 70.95,61.28 71.15,61.47 R18.1
N13081672: length 4.6
  BOTTOM w1: R17.2 91.7,57.4 92.8,56.3 R20.1
N13081716: length 10.1
  BOTTOM w0.7: R21.2 77.07,67.1 C22.1 ; C22.1 74.51,64.53 R18.2 ; C22.1 C23.1
N13081774: length 2.4
  BOTTOM w1: C20.1 71.15,58.8 71.56,58.38 71.56,57.32 U3.14
N13081806: length 6.6
  BOTTOM w1: R22.1 89.35,45.57 92.8,49.02 R20.2
N13081894: length 2.7
  BOTTOM w1: R21.1 78.32,70.48 D5.1
N13081936: length 22.2
  TOP w0.305: D22.2 81.07,45.29 U3.2
  BOTTOM w0.305: U3.2 81.05,45.31 81.05,44.95
  BOTTOM w0.381: C100.1 80.14,42.66 81.05,43.57 81.05,44.95
  BOTTOM w0.508: C100.1 R154.1 80.14,39.4 80.14,39.39 80.14,39.14 81.5,37.78 R77.2 R65.1
  BOTTOM w1: R22.2 85.51,46.1 84.32,47.29 81.95,47.29 80.95,46.29 80.95,45.41 U3.2
N13081966: length 13.5
  BOTTOM w0.381: R111.1 119.95,78.62 119.95,78.61 C102.1 127.28,78.61 R157.2
  BOTTOM w0.508: R157.2 128.09,78.92 129.69,77.32 129.69,76.25 C115.1
N13082106: length 3.3
  BOTTOM w0.508: T1.12 131.44,79.43 R157.1
N13082142: length 49.1
  TOP w0.305: 67.75,44.95 67.75,45.31 U3.9
  TOP w0.381: v4(63.8,43.33) 67.32,43.33 67.75,43.77 67.75,44.95
  BOTTOM w0.381: 56.86,46.48 60.01,43.33 v4(63.8,43.33) ; D4.2 55.94,71.29 57.84,69.39 61.04,69.39 62.53,67.89 62.53,61.67 56.86,56 56.86,54.51
  BOTTOM w0.432: 56.86,54.51 54.73,52.37 54.73,48.64 56.86,46.51 56.86,46.48
N13082252: length 7.1
  BOTTOM w0.305: R29.1 74.46,43.11 75.14,43.79 75.14,45.16 U3.5
N13082394: length 7.3
  BOTTOM w0.305: U3.8 69.65,45.31 69.65,44.95
  BOTTOM w0.508: R24.1 71.53,40.09 C24.1 69.29,42.94 69.65,43.3 69.65,44.95
N13082422: length 2.9
  BOTTOM w0.508: R23.1 66.25,34.97 66.25,35.68 67.12,36.55 D6.2
N13082998: length 62.6
  TOP w0.381: v3(125.98,17.47) 125.27,18.18 125.27,27.23 116.94,35.56 116.94,38.38 114.63,40.69 114.63,44.78 111.38,48.03 v3(108.67,48.03)
  BOTTOM w0.381: R79.1 v3(125.98,17.47) 125.98,14.79 122.92,11.73 122.92,10.2 121.6,8.88 120.03,8.88 118.54,7.39 118.54,1.91 119.06,1.39 R88.1
N13083006: length 1.9
  BOTTOM w0.508: D19.1 R88.2
N13083046: length 15.4
  BOTTOM w0.508: U9.4 94.08,48.03 88.95,42.9 R155.1 R156.2
N13083116: length 1.9
  BOTTOM w0.508: R79.2 128.85,20.77 VR5.2
N13083120: length 4.4
  BOTTOM w0.508: VR5.1 129.5,24.92 130.54,24.92 D18.1 130.63,25.96 131.39,26.71 C56.1
N13129300: length 8.9
  BOTTOM w0.305: 144.85,60.2 144.81,60.82 143.9,61.74 142.91,61.74
  BOTTOM w0.508: Q10.3 142.33,61.69 143,61.02 FL1.1 ; 145.6,60.07 144.85,60.07 ; 144.85,60.07 144.85,60.2 ; 144.85,60.07 144.55,60.07
  vias: v3(140.73,50.81) v3(140.73,50.11) v3(141.4,57.9) v3(141.38,57.17) v3(141.4,56.41) v3(141.4,55.71) v3(141.4,55.01) v3(141.4,54.31) v3(141.4,53.61) v3(141.4,52.91) v3(141.4,52.21) v3(141.4,51.51) v3(141.43,50.81) v3(141.43,50.11) v3(142.13,56.46) v3(142.13,55.71) v3(142.13,55.01) v3(142.13,54.31) v3(142.13,53.61) v3(142.13,52.91) v3(142.13,52.21) v3(142.13,51.51) v3(142.13,50.81) v3(142.13,50.11) v3(142.27,57.48)
N13129338: length 12.8
  BOTTOM w0.254: 153.47,4.42 153.48,4.42 MTG_HOLE5.1
  BOTTOM w1.27: C107.1 157.84,11.21 C106.2 156.98,7.93 153.47,4.42
N13129680: length 3.6
  BOTTOM w1: R90.2 159.92,59.05 158.46,60.51 158.46,60.51 VR11.1
N13130082: length 12
  BOTTOM w0.304: R39.2 134.9,71.5 134.9,69.79 R41.1
  BOTTOM w0.508: Q6.1 136.57,77.27 136.02,76.72 136.02,72.99 R39.2
N13130158: length 4.1
  BOTTOM w0.381: Q7.1 137.79,64.56 R44.1 134.43,64.56 R40.2
N13130170: length 4.2
  BOTTOM w0.381: Q7.2 136.22,66.22 R44.2 135.05,65.99 134.99,66.05 R46.1
N13130230: length 22.3
  TOP w0.305: v3(132,69.2) 126.16,63.36 v2(114.94,63.36)
  BOTTOM w0.305: U6.8 114.93,63.35 v2(114.94,63.36) ; R41.2 v3(132,69.2)
N13130322: length 20.5
  TOP w0.305: v3(131.77,66.05) 127.67,61.95 v2(114.91,61.95)
  BOTTOM w0.305: v2(114.91,61.95) 114.81,61.85 U6.10
N13130482: length 6.4
  BOTTOM w0.508: R52.1 R50.2 137.64,53.18 137.65,53.17 Q9.1
N13130510: length 11.3
  BOTTOM w0.305: 115.44,67.47 115.44,68.83 116.59,69.98 C40.1
  BOTTOM w0.381: U6.4 114.32,66.35 115.44,67.47
  BOTTOM w0.508: C40.1 118.7,69.98 R58.1 119.29,71.13 R104.1
N13130530: length 8.4
  BOTTOM w0.381: Q10.1 137.08,60.92 R54.1 135,60.66 130.48,60.66 130.12,61.01 R49.2
N13130550: length 4.1
  BOTTOM w0.381: Q10.2 137.25,62.62 135.54,62.62 R54.2 135.25,62.33 133.73,62.33 R57.1
N13130620: length 26.3
  TOP w0.305: v2(127.3,62.6) v2(114.48,62.6)
  BOTTOM w0.305: U6.9 v2(114.48,62.6)
  BOTTOM w0.381: 134.66,59.94 128.37,59.94 127.3,61.01 v2(127.3,62.6)
  BOTTOM w0.4: R52.2 136.42,58.18 134.66,59.94
N13130700: length 2.3
  BOTTOM w0.508: C41.1 123.44,71.42 R58.2
N13130736: length 18.6
  TOP w0.305: v7(114.58,61.1) 130.19,61.1 v3(130.99,61.9)
  BOTTOM w0.381: R57.2 131.16,61.9 v3(130.99,61.9) ; v7(114.58,61.1) U6.11
N13130824: length 5.6
  BOTTOM w0.381: U6.3 111.36,67.1 110.49,67.97 R61.1
N13130832: length 1.7
  BOTTOM w0.381: R61.2 R62.1
N13130836: length 2.3
  BOTTOM w0.381: R63.1 111.16,76.28 110.49,75.62 R62.2
N13130840: length 1.8
  BOTTOM w0.381: R63.2 114.43,76.28 114.45,76.3 C44.2
N13131010: length 10.4
  TOP w0.381: v2(122.55,65.44) 121.24,64.13 115.39,64.13 v2(114.68,64.85)
  BOTTOM w0.254: R66.1 v2(122.55,65.44)
  BOTTOM w0.381: v2(114.68,64.85) U6.6
N13134664: length 3.1
  BOTTOM w0.508: R85.2 125.24,5.17 R42.1 123.76,5.17 C28.2
N13134676: length 2.1
  BOTTOM w0.7: R42.2 126.77,5.07 126.77,4.08 J10.4
N13134874: length 3.6
  BOTTOM w0.508: R45.1 130.25,5.23 130.25,6.71 R87.2 131.57,6.79 131.7,6.66 C55.2
N13134886: length 2.4
  BOTTOM w0.508: J10.5 129.7,3.42 128.77,4.36 R45.2
N13135254: length 3.9
  BOTTOM w0.4: R51.1 102.36,2.24 101.9,1.78 99.97,1.78 R35.2
N13135288: length 17
  TOP w0.304: v3(117.32,9.68) 117.32,10.97 114.15,14.15 114.15,20.46 T2.7
  BOTTOM w0.508: R32.1 117.07,9.67 116.53,9.13 115.58,9.13
N13135376: length 3.5
  BOTTOM w1: D15.1 97.7,22.94 R26.2
N13135402: length 0.5
  BOTTOM w0.381: v2(119.61,19.43) 119.58,19.46 Q12.4
N13135462: length 8.2
  TOP w0.508: R127.2 118.06,16.94 117.55,16.43 117.55,16.41 117.09,15.95 R126.2 115.62,15.95 114.84,15.17 v2(114.84,14.63)
  BOTTOM w0.381: U10.5 v2(114.84,14.63)
N13135530: length 10.9
  TOP w0.635: T2.1 99.08,34.77 96.98,34.77 v5(94.62,37.14)
  BOTTOM w0.635: v5(94.62,37.14) D3.2
N13135582: length 5.5
  BOTTOM w0.508: VR2.1 66.88,30.71 R19.2 69.25,30.71 69.58,30.38 Q2.1
N13136072: length 1.8
  BOTTOM w0.508: C10.1 120.52,13.51 120.52,12.31 120.37,12.16 R27.2
N13136170: length 10.6
  BOTTOM w0.305: R30.2 120.32,14.96 120.32,14.96 C10.2 R43.1 C33.1 117.86,16.56 117.42,16.13 U10.3
N13136174: length 3.5
  BOTTOM w0.508: D24.1 107.92,5.03 107.47,5.48 R84.2 R55.1
N13136212: length 5
  BOTTOM w0.304: 114.67,13.12 113.4,13.12 U10.7
  BOTTOM w0.305: 114.67,13.12 115.33,12.47 115.33,11.92 115.72,11.53 116.67,11.53 117.11,11.1 R32.2
N13136306: length 3.5
  BOTTOM w0.305: U10.4 115.42,15.38 C31.2
N13136428: length 2.1
  BOTTOM w0.381: R55.2 105.6,2.55 104.86,3.3 VR1.1
N13136440: length 10.6
  BOTTOM w0.4: C52.1 99.38,10.12 U10.14 102.75,10.12 103.63,9.25 103.63,7.47 104.3,6.8 VR1.2 106.08,6.8 R84.1
N13140087: length 4
  BOTTOM w0.4: 101.88,8.66 101.87,8.66 101.16,9.38 U10.13
  BOTTOM w0.762: R51.2 102.36,8.18 101.88,8.66
N13191912: length 12
  BOTTOM w0.305: U5.2 121.55,54.35 120.87,53.67 115.64,53.67 C39.1
  BOTTOM w0.381: C39.1 115.57,51.82 R59.2 ; U5.2 121.55,56.78 122.4,57.63 R151.2
N13191920: length 7.7
  BOTTOM w0.305: R147.1 119.75,54.53 120.28,55.06 U5.1
  BOTTOM w0.381: R147.1 116.92,54.53 116.54,54.91 115.81,54.91 C39.2 114.89,55.84 C42.1
N13192176: length 2
  BOTTOM w0.381: R59.1 113.78,52.12 C42.2
N13192240: length 4
  BOTTOM w0.508: U7.3 139.8,29.18 C103.1 140.28,29.67 141.29,29.67 R139.2
N13192354: length 2.9
  BOTTOM w0.305: D9.2 112.27,55.61 112.57,55.92 112.57,56.53 113.59,57.55 R60.1
N13192496: length 2.7
  BOTTOM w0.381: R137.1 124.23,57.64 122.82,56.23 U5.3
N13192500: length 1.7
  BOTTOM w0.508: R140.2 135.51,27.55 v3(135.51,29.18)
N13192960: length 2
  BOTTOM w0.508: R131.2 130.7,42.62 R128.1
N13193004: length 3.7
  BOTTOM w0.508: R130.1 129.29,42.38 129.27,42.39 R128.2 129.27,44.93 R132.1
N13193032: length 8.1
  BOTTOM w0.381: U5.5 124.09,49.92 124.47,49.54 R76A.1
  BOTTOM w0.508: R132.2 129.29,48.63 128.37,49.54 R76A.1
N13193186: length 11.1
  TOP w0.381: v3(127.2,48.03) v3(127.2,51.56) v2(127.2,56.36)
  BOTTOM w0.305: R68.1 128.12,56.51 128.72,55.91 R76.2
N13193272: length 19.2
  BOTTOM w0.304: 116.79,51.97 116.76,51.94 116.76,50.98 116.43,50.65
  BOTTOM w0.305: 116.79,51.97 117.93,53.11 120.07,53.11 121.55,51.63 U5.7 ; R91.2 116.43,50.65
  BOTTOM w0.381: R135.2 C112.2 C113.1 121.84,48.64 121.55,48.94 U5.7
N13193284: length 3.5
  BOTTOM w0.508: R91.1 111.54,52.83 R133.2 109.62,51.33 R134.2
N13193324: length 12.2
  BOTTOM w0.381: C113.2 123.27,48.51 122.82,48.96 U5.6 122.82,51.65 123.52,52.35 R69.2
  BOTTOM w0.508: R150.2 127.1,45.77 126.19,46.69 126.19,47.53 125.71,48.01 R70.2 C113.2
N13193524: length 4.6
  BOTTOM w0.381: C112.1 R135.1
  BOTTOM w0.508: R70.1 124.54,46.15 124.54,45.34 123.95,44.75 R135.1
N13193682: length 4.2
  BOTTOM w0.508: R150.1 R145.2 127.18,42.49 126.68,42 R153.2
N13193934:
  vias: v4(123.6,33.2)
N13193966: length 2.1
  BOTTOM w0.508: Q3.3 122.43,36.3 D21.2
N13193994: length 2.3
  BOTTOM w0.508: D23.2 121.23,30.54 Q5.3
N13194026: length 5.4
  TOP w0.508: R96.2 124.59,31.78 v4(125.24,31.13) 125.56,31.44 VR8.1
  BOTTOM w0.508: Q3.1 124.68,30.57 v4(125.24,31.13)
N13194030: length 7.5
  BOTTOM w0.508: VR7.1 115.44,38.84 115.85,38.43 R98.1 117.1,36.41 118.41,35.11 Q5.1
N13194134: length 2.3
  BOTTOM w0.381: C64.1 120.79,62.4 R97.2
N13204238: length 1.6
  BOTTOM w0.381: D20.2 109.62,55.01 R133.1
N13219296: length 4.8
  BOTTOM w0.381: R60.2 115.01,57.55 115.73,56.83 116.29,56.83 117.17,55.96 R147.2 118.06,55.96 118.49,55.52 C114.1
N13249684: length 8.1
  BOTTOM w0.508: R28.1 132.03,22.82 132.62,22.82 134.21,21.23 134.21,18.21 135.1,17.32 D7.1
N13249824: length 7.6
  BOTTOM w0.7: Q11.3 124,11.68 126.13,13.81 RL2.3 126.82,14 D10.2
N13249932: length 3.7
  BOTTOM w0.305: Q11.1 127.77,11.58 R72.1 R71.2
N13259403: length 16.4
  BOTTOM w0.635: C62.1 156.5,61.88 156.87,62.26 159.72,62.26 160.35,62.89 160.35,66.19 D14.1
  BOTTOM w1.27: C62.1 156.46,59.51 156.62,59.35 R90.1 153.8,57.7 D13.1
N13332978: length 1.5
  BOTTOM w0.508: R155.2 86.04,42.94 Q13.1
N13335649: length 1.9
  BOTTOM w0.508: Q13.3 81.56,41.28 R154.2

## Copper pours and planes (outline as drawn)
+12V on BOTTOM: 119.2,27.25 120.07,28.12 119.02,29.16 116.51,29.16 116.28,28.93 116.28,27.36 116.38,27.25
GND_EARTH on BOTTOM: 7.42,60.45 8.61,59.26 8.61,44.78 8,44.17 2.08,44.17 0.53,45.72 0.56,45.75 0.56,78.51 2.51,80.47 3.91,80.47 4.98,79.4 4.98,77.47 2.69,75.18 2.69,62.51 4.75,60.45
AUX_PRI on BOTTOM (solid shape): 77.28,32.03 72.45,32.03 72.45,33.3 77.28,33.3
AUX_PRI on BOTTOM: 79.04,30.81 79.12,30.89 79.12,35.97 78.94,36.14 74.19,36.14 73.94,35.89 73.94,33.91 73.33,33.3 70.51,33.3 69.75,32.54 68.83,32.54 68.76,32.46 68.76,31.83 68.86,31.72 69.72,31.72 69.97,31.97 73.57,31.97 74.73,30.81
BAT+ on TOP: 138.18,17.02 138.71,17.55 142.9,17.55 144.02,16.43 144.02,8.89 143.56,8.43 135.69,8.43 134.09,10.03 132.94,10.03 132.38,10.59 131.34,10.59 130.91,11.02 130.91,12.4 131.14,12.62 137.34,12.62 138.18,13.46
BAT+ on BOTTOM: 138.17,16.99 138.18,17.02 138.71,17.55 142.9,17.55 144.02,16.43 144.02,8.89 143.56,8.43 135.69,8.43 134.09,10.03 132.94,10.03 132.38,10.59 131.34,10.59 130.91,11.02 130.91,12.4 131.14,12.62 137.34,12.62 138.17,13.46
BAT- on TOP: 149.3,24.11 149.54,24.35 155.07,24.35 156.06,25.34 156.06,28.37 156.52,28.83 159.95,28.83 160.02,28.75 160.02,19.83 158.48,18.28 149.66,18.28 149.3,18.64
BAT- on BOTTOM: 147.5,18.77 147.5,23.75 148.1,24.35 155.07,24.35 156.06,25.34 156.06,28.37 156.52,28.83 159.95,28.83 160.02,28.75 160.02,19.83 158.48,18.28 147.99,18.28
CS+ on TOP: 152.81,29.87 154.72,27.95 154.72,25.21 154.31,24.79 148.44,24.79 147.9,25.32 147.9,27.2 150.57,29.87
CS+ on BOTTOM: 144.3,32.87 149.82,32.87 151.13,31.57 151.13,29.9 151.16,29.87 152.81,29.87 154.72,27.95 154.72,25.23 154.3,24.8 148.6,24.8 147.1,26.3 147.1,28.74 146.89,28.95 144.14,28.95 144.02,29.08 144.02,32.59
D5 on TOP: 153.21,66.83 153.21,63.91 152.11,62.8 148.37,62.8 147.47,63.7 147.47,65.18 146.91,65.74 142.16,65.74 141.1,66.8 141.1,73.32 140.61,73.8 138.77,73.8 138.45,74.12 138.45,75.2 138.85,75.6 142.97,75.6 143.22,75.35 143.22,69.07 143.49,68.8 151.24,68.8
D5 on BOTTOM: 146.98,65.9 142.06,65.9 141.1,66.8 141.1,73.32 140.61,73.8 138.45,74.12 138.45,75.2 138.85,75.6 142.97,75.6 143.22,75.35 143.22,69.07 143.49,68.8 151.24,68.8 153.21,66.83 153.21,63.89 152.11,62.79 152.11,62.8 148.37,62.8 147.47,63.7 147.47,65.41
GP on TOP: 95.38,63.19 95.38,65.32 96,65.94 100.56,65.94 101.45,65.05 101.45,62.72 101.17,62.44 99.02,62.44 98.69,62.77 95.8,62.77
GP on BOTTOM: 98.86,62.59 98.57,62.88 98.57,63.69 98.33,63.93 95.79,63.93 95.57,64.16 95.57,65.48 96.01,65.92 100.55,65.92 100.99,65.49 100.99,65.48 100.99,62.64 100.94,62.59
GSA on BOTTOM (solid shape): 119.79,21.03 118.87,21.03 118.87,23.95 119.79,23.95
GSA on TOP: 139.9,65.68 139.9,59.63 139.87,59.63 137.6,57.35 137.62,57.33 137.62,49.43 137.85,49.2 142.19,49.2 142.49,48.89 142.49,44.5 143.59,43.41 150.6,43.41 151.12,42.88 151.12,37.67 150.01,36.56 139.17,36.56 138.55,37.17 138.55,40.3 135.48,43.37 135.48,72.51 135.97,73 140,73 140.4,72.6 140.4,65.82 140.33,65.76 139.98,65.76
GSA on BOTTOM: 144.27,40.55 150.82,40.55 151.13,40.24 151.13,37.49 151.6,37.03 151.91,36.72 153.68,36.72 154.37,36.03 154.37,30.48 154.27,30.38 152.12,30.38 152.08,30.42 152.08,32.82 149.98,34.92 144.2,34.92 144.2,35.59 143.94,35.84 143.94,40.22
GSA on BOTTOM: 120.82,18.8 114.13,18.8 113,17.68 113,16.83 113.15,16.68 117.01,16.68 117.26,16.92 117.26,17.42 117.41,17.58 121.03,17.58 121.03,18.59
GSA on BOTTOM: 120.69,26.25 118.85,26.25 118.75,26.15 118.75,21.08 118.85,20.98 123.34,20.98 123.34,24.28 123.24,24.28 122.61,24.92 122.61,27.2 122.5,27.3 121.18,27.3 121.06,27.18 121.06,26.62
GSA on BOTTOM: 135.65,67.85 135.9,67.6 139.8,67.6 140.4,68.2 140.4,72.6 140,73 138,73 137.5,72.5 137.5,70.4 137.3,70.2 136.97,70.2 136.84,70.33 136.84,71.16 136.7,71.3 135.79,71.3 135.54,71.05 135.54,70.04 135.66,69.93 135.66,69.88 135.65,69.86
OUT+ on TOP: 145.57,25.48 145.67,25.58 150.45,30.35 150.48,30.38 158.58,30.38 160.07,31.87 160.07,44.47 159.8,44.75 152,44.75 151.85,44.6 151.85,37.03 145.12,30.3 141.73,30.3 141.25,29.82 141.25,25.7 141.48,25.48
OUT+ on TOP: 132.56,44.7 132.56,44.7 130.91,46.35 130.91,58.59 131.48,59.16 134.14,59.16 134.86,58.44 134.86,44.81 134.75,44.7
OUT+ on BOTTOM: 139.61,27.69 139.38,27.46 139.38,26.14 140.04,25.47 145.57,25.47 146.4,26.3 146.4,28.22 146.02,28.6 141.66,28.6 140.76,27.69
OUT+ on BOTTOM: 130.22,58.05 131.22,59.05 134.3,59.05 135.5,57.85 135.5,45.15 135.9,44.75 159.8,44.75 160.07,44.47 160.07,31.87 158.58,30.38 155.32,30.38 155.3,30.4 155.3,36.24 154.18,37.36 152.1,37.36 151.97,37.49 151.97,37.49 151.84,37.62 151.84,40.36 151.15,41.05 139.6,41.05 138.25,39.7 138.25,33.32 137.95,33.02 134.72,33.02 134.44,33.3 134.44,35.46 134.19,35.71 132.18,35.71 132.11,35.79 132.11,38.43 132.61,38.94 132.61,43.29 130.52,45.39
OUT++ on TOP, BOTTOM: 145.01,24.87 146.3,23.57 146.3,18.95 145.79,18.44 139.26,18.44 138.77,18.93 137.38,20.32 135.46,20.32 135.1,20.68 135.1,25.07 135.66,25.63 137.13,25.63 137.9,24.87
RTN on TOP (solid shape): 83.72,17.59 83.72,15.75 83.72,15.75 84.15,15.32 84.15,15.04 84.02,14.91 82.73,14.91 81.9,15.74 81.9,17.03 81.65,17.27 81.64,17.27 81.64,17.68 82.05,18.08 83.23,18.08
RTN on TOP: 38,13.8 43.62,13.8 43.62,13.87 56.2,20.8 69.85,20.85 73.4,17.3 74.98,17.3 75.05,18.38 70.05,23.38 55.04,23.39 43.62,16.42 41.97,16.42 41.5,17.3 61.17,30.52 61.17,45 57.8,48.38 57.8,53.38 70.74,66.32 70.87,66.32 70.94,66.24 70.94,66.12 64.03,59.21 64.03,55.91 64.49,55.45 65.85,55.45 66.45,56.05 66.45,56.06 66.61,56.22 66.61,58.19 72.12,63.7 82.56,63.7 83.62,62.64 85.33,62.64 86.27,63.58 86.27,65.15 85.14,66.28 78.47,66.28 75.24,69.5 70.31,69.5 62.01,61.2 56.58,61.2 52.96,57.84 52.96,48.44 57.4,44 57.4,31.29 38,17.51
RTN on TOP: 83.27,12.52 84.37,12.52 84.7,12.85 84.7,14.77 83.72,15.75 83.72,17.57 83.72,17.57 83.72,17.6 81.12,20.2 76.15,20.2 75.22,19.27 72.87,19.27 72.37,18.77 72.37,18.31 73.39,17.3 76.4,17.3 77.12,18.02 80.91,18.02 81.9,17.03 81.9,15.74 82.93,14.71 82.87,12.92
RTN on TOP: 109.12,7.37 109.12,1.18 108.86,0.93 101.75,0.93 101.35,1.33 101.35,8.23 99.72,9.85 96.95,9.85 96.07,10.72 96.07,15.85 97.31,15.85 98.83,14.33 104.85,14.33 104.98,14.2 104.98,11.51
RTN on TOP: 21.77,5.21 22.07,5.51 35.11,5.51 38,8.4 38,14.3 42.3,14.3 42.3,8.4 35.1,1.2 23.9,1.2 21.77,2.83
RTN on BOTTOM: 97.6,14.18 97.6,12.68 97.95,12.33 99.42,12.33 99.42,12.25 100.2,11.48 102.75,11.48 103.02,11.75 103.02,13.63 102.37,14.28 97.7,14.28
RTN on BOTTOM: 56.39,61.16 57.25,61.16 57.76,60.66 57.76,58.04 55.83,56.11 54.53,56.11 54.28,56.36 54.28,59.05
VBULK on TOP: 57.43,69.72 49.02,61.81 49.02,41 50.67,39.35 50.67,35.66 44.89,29.88 39.43,29.88 33.76,24.21 33.1,24.21 32.74,23.85 32.74,21.49 33.02,21.21 35.26,21.21 35.66,21.62 35.66,22.22 40.26,26.82 46.38,26.82 55.17,35.61 55.17,41.35 51.4,45.12 51.4,59.03 56.83,64.46 61.87,64.46 61.87,64.47 62.86,64.47 72.29,73.89 75.22,73.89 79.18,69.92 83.95,69.92 88.8,65.08 88.8,62.62 84.47,58.3 82.37,58.3 82.02,57.95 81.9,57.78 81.9,56.37 82.55,55.73 86.07,55.73 92.4,62.05 92.4,65.62 85.77,72.25 81.92,72.25 76.67,77.5 71.43,77.5 65.98,72.05 65.98,71.01 64.69,69.72
VBULK on BOTTOM: 54.94,41.45 54.94,39.98 54.58,39.62 54,39.62 53.72,39.34 53.72,38.53 53.67,38.48 53.29,38.48 53.21,38.56 53.21,39.65 53.14,39.73 52.98,39.73 52.9,39.64 52.9,29.6 65.52,16.98 70.86,16.98 71.66,16.17 77.45,16.17 78.75,14.88 78.75,12.42 78.47,12.15 77.47,12.15 75.77,13.85 66.07,13.85 63.75,16.17 59.3,16.17 48.92,26.55 48.92,27.15 48.87,42.63 49.17,42.93 53.47,42.93
VBULK on BOTTOM: 55.04,67.26 59.41,67.26 60.17,66.5 60.17,66.22 59.77,65.81 59.77,64.97 59.13,64.34 55.07,64.34 54.74,64.67 54.74,66.95
VBULK on BOTTOM: 96.98,33.86 98.4,33.86 98.53,33.73 98.53,27.05 98.76,26.82 101.98,26.82 102.49,26.31 102.49,25.45 101.94,24.9 100.79,24.9 100.39,25.3 97.08,25.3 96.93,25.45 96.93,33.81
VBULK on BOTTOM: 71.17,77.19 71.17,75.01 71.35,74.83 76.1,74.83 76.38,75.11 76.38,77.01 75.95,77.44 71.42,77.44
VRECT on BOTTOM: 21.82,18.06 21.82,21.16 25.3,24.64 27.41,24.64 28.52,23.52 28.52,21.29 31.75,18.06 35.33,18.06 38.35,21.08 38.37,21.07 38.37,23.99 39.52,25.15 41.1,25.15 42.29,23.95 42.29,19.23 34.7,11.63 31.37,11.63 27.33,15.67 27.33,16.76 26.39,17.7 25.37,17.7 25.27,17.81 25.27,19.99 25.2,20.07 25.07,20.07 24.99,19.99 24.99,17.75 24.94,17.7 22.17,17.7
N13075197 on BOTTOM: 6.73,71.63 11.23,71.63 11.66,71.2 11.66,69.29 8.99,66.62 8.99,63.63 8.84,63.47 5.87,63.47 5.82,63.53 5.82,70.71
N13075201 on BOTTOM: 19.91,78.77 39.22,78.77 43.48,74.5 44.5,74.5 44.53,74.52 45.4,74.52 48.87,77.99 51.6,77.99 52.2,78.59 52.2,79.6 52.15,79.6 51.61,80.14 47.6,80.14 44.42,76.96 44.07,76.96 40.65,80.38 12.2,80.38 10.06,78.23 10.06,74.4 10.49,73.96 12.17,73.96 12.46,74.26 12.46,76.54 13.06,77.14 13.84,77.14 14.53,76.45 17.6,76.45
N13075229 on BOTTOM: 33.99,66.3 32.49,66.3 31.9,66.88 31.9,70.82 32.64,71.56 33.78,71.56 34.52,70.82 34.52,69.65 34.85,69.32 34.85,68.76 34.78,68.68 34.29,68.68 34.21,68.61 34.21,66.53
N13075229 on BOTTOM: 31.9,72.62 31.9,70.08 32.46,69.52 33.63,69.52 34.52,70.41 34.52,71.68 34.54,71.68 36.6,73.74 36.83,73.74 36.91,73.66 36.91,72.19 43.18,65.91 44.5,65.91 49.58,70.99 49.58,71.96 49.02,72.52 48.18,72.52 44.35,68.68 43.24,68.68 38.93,73 38.93,75.48 37.82,76.58 35.86,76.58
N13075257 on TOP: 37.49,45.31 42.44,50.27 43.38,50.27 44.4,49.25 44.4,48.49 39.19,43.28 17.86,43.28 16.54,44.6 16.54,45.69 17.14,46.3 18.26,46.3 19.25,45.31
N13075257 on BOTTOM: 31.93,60.91 32.61,60.22 33.88,60.22 34.67,61.01 34.67,62.11 34.58,62.19 34.57,62.18 34.39,62.18 34.24,62.33 34.24,64.59 33.99,64.85 32.36,64.85 31.93,64.41
N13075257 on BOTTOM: 43.93,50.27 44.4,49.79 44.4,48.06 44.17,47.83 43.85,47.83 43.47,47.45 43.47,44.5 43.37,44.4 41.44,44.4 41.34,44.5 41.34,49.25 41.35,49.26 41.35,49.61 42.01,50.27
N13075257 on BOTTOM: 43.03,47.73 43.03,47.88 44.4,49.25 44.4,57.33 41.38,60.35 35.69,60.35 34.19,61.85 32.49,61.85 31.93,61.29 31.93,60.53 34.14,58.32 39.17,58.32 41.33,56.16 41.33,48.46 42.06,47.73
N13075293 on TOP: 24.26,15.67 25.04,14.88 25.04,13.23 24.03,12.22 18.24,12.22 15.93,14.53 15.93,16.56 16.61,17.25 19.23,17.25 20.8,15.67
N13075293 on BOTTOM: 37.71,37.21 37.71,38.48 37.93,38.71 41.19,38.71 41.42,38.94 41.42,42.13 41.59,42.29 41.59,42.29 41.72,42.42 43.19,42.42 43.48,42.13 43.48,39.12 44.4,38.2 44.4,36.89 44.14,36.63 41.63,36.63 41.1,37.16 37.76,37.16
N13075293 on BOTTOM: 42.04,39.07 43.41,39.07 44.4,38.07 44.4,36.47 39.17,31.24 36.53,31.24 34.63,29.35 32.58,29.35 31.75,30.18 31.75,31.62 35.15,35.03 38,35.03 39.84,36.87 41.08,36.87 41.15,36.93 41.15,38.18
N13075321 on BOTTOM: 20.68,10.64 24.16,10.64 24.94,9.86 24.94,8.33 24.1,7.49 17.45,7.49 16.28,8.66 16.28,14.15 1.97,28.46 1.16,28.46 0.23,29.39 0.23,30.84 1.7,32.31 4,32.31 5.11,31.2 19.76,16.55 19.76,11.56
N13075467 on BOTTOM (solid shape): 39.29,42.65 37.11,42.65 37.11,43.26 37.62,43.26 37.62,46.46 37.11,46.46 37.11,47.07 39.29,47.07
N13075467 on BOTTOM: 39.27,47.06 37.14,47.06 37.11,47.04 37.11,40.77 37.4,40.48 39.12,40.48 39.12,40.49 39.25,40.49 39.35,40.58 39.35,46.99
N13075621 on BOTTOM: 20.19,52.5 21.39,52.5 22.43,53.54 22.43,60.15 22.1,60.48 18.34,60.48 17.55,61.26 17.55,69.85 21.87,74.17 22.76,74.17 24.94,71.98 24.94,70.05 25.32,69.67 25.32,69.65 27.23,69.65 27.56,69.98 27.56,72.54 23.55,76.56 21.39,76.56 15.24,70.41 15.24,58.12 16.13,57.23 18.92,57.23 19.41,56.74 19.41,53.29
N13075621 on BOTTOM: 25.48,66.3 26.97,66.3 27.56,66.88 27.56,70.82 26.82,71.56 25.68,71.56 24.94,70.82 24.94,69.65 24.61,69.32 24.61,68.76 24.69,68.68 25.17,68.68 25.25,68.61 25.25,66.53
N13075629 on BOTTOM: 25.45,64.7 26.95,64.7 27.53,64.11 27.53,60.91 26.85,60.22 25.58,60.22 24.79,61.01 24.79,62.11 24.88,62.19 24.89,62.18 25.07,62.18 25.22,62.33 25.22,64.47
N13075629 on BOTTOM: 25.2,61.93 25.2,56.72 26.87,55.04 26.87,49.56 27.38,49.05 29.87,49.05 30.28,49.45 30.28,55.58 27.53,58.32 27.53,61.7 27.08,62.15 25.43,62.15
N13075629 on BOTTOM: 29.34,47.9 29.97,48.54 29.97,49.76 29.46,50.27 26.9,50.27 26.72,50.09 19.84,50.09 19.3,50.62 19.3,50.65 18.03,51.92 17.14,51.92 16.56,51.33 16.56,50.29 18.92,47.93 18.97,47.93 19,47.9
N13075629 on BOTTOM: 26.62,47.12 26.67,47.07 27,47.07 27.36,47.42 27.83,47.42 28.03,47.22 28.03,44.5 28.13,44.4 30.06,44.4 30.16,44.5 30.16,50.18 29.84,50.5 27.57,50.5 26.62,49.54
N13075705 on BOTTOM: 33.35,38.71 30.48,38.71 30.07,39.12 30.07,42.13 29.91,42.29 28.18,42.29 28.02,42.13 28.02,36.04 28.19,35.86 29.49,35.86 30.78,37.16 33.3,37.16 33.38,37.24 33.38,38.68
N13075705 on BOTTOM: 19.68,30.51 17.59,28.42 13.49,28.42 12.47,29.44 12.47,31.09 13.35,31.97 13.36,31.97 13.55,32.16 18.34,32.16 18.55,32.37 18.55,35.35 21.46,38.26 22.24,39.04 27.38,39.04 27.43,39.09 27.43,39.34 27.51,39.42 28.83,39.42 29.84,38.4 29.84,36.35 29.36,35.86 25.04,35.86
N13075741 on BOTTOM (solid shape): 34.09,46.43 33.58,46.43 33.58,43.23 34.09,43.23 34.09,42.62 31.9,42.62 31.9,47.04 34.09,47.04
N13075741 on BOTTOM: 34.04,47.07 31.91,47.07 31.89,47.04 31.89,40.67 32.06,40.49 33.89,40.49 34.12,40.72 34.12,46.99
N13076615 on TOP: 75.27,9.98 76.6,8.65 80.72,8.65 81.6,9.52 81.6,14.28 81.22,14.65 80.52,14.65 80.22,14.35 80.22,11.45 79.95,11.18 76.92,11.18 75.55,12.58 65.5,12.58 64.32,11.4 64.32,7.04 64.56,6.8 67.44,6.8 70.1,9.98
N13077081 on BOTTOM (solid shape): 83.31,29.84 82.04,29.84 82.04,34.66 83.31,34.66
N13077081 on BOTTOM: 82.04,30.3 80.8,31.54 80.8,36.32 80.92,36.45 84.3,36.45 84.48,36.27 84.48,31.57 83.29,30.38 83.29,27.97 84.12,27.13 85.52,27.13 85.67,26.97 85.67,26.09 85.42,25.83 83.03,25.83 82.93,25.93 82.93,27.08 82.04,27.97
N13081712 on BOTTOM: 92.2,74.57 86.43,68.81 83.24,68.81 80.8,66.37 80.8,62.38 80.41,62 72.7,62 72.7,56.82 73,56.52 73.92,56.52 74.2,56.8 74.2,59.13 74.9,59.82 81.54,59.82 82.82,61.1 82.82,62.61 82.8,62.62 82.8,65.38 84.09,66.67 89.24,66.67 93.37,70.8 97.65,70.8 98.95,72.1 98.95,74 98.37,74.57
N13081802 on BOTTOM: 84.29,76.45 99,76.45 99.12,76.57 99.12,80.1 98.87,80.35 84.29,80.35 84,80.06 83.96,80.06 83.96,76.78
N13129300 on TOP: 141,51.56 140.88,51.45 139.02,51.45 138.65,51.08 138.65,50.15 139.02,49.78 142.28,49.78 142.57,50.06 142.57,57.38 143,57.81 145.66,57.81 147.28,59.44 147.28,61.25 145.47,63.06 142.33,63.06 141,61.72
N13129300 on BOTTOM: 140.62,61.35 140.62,56.03 140.99,55.65 140.99,51.59 141,51.59 140.86,51.45 139.02,51.45 138.65,51.08 138.65,50.15 139.02,49.78 143.15,49.78 143.35,49.98 143.35,56.1 144.02,56.78 149.56,56.78 150.32,57.54 150.32,59.03 150.14,59.21 149.33,59.21 145.47,63.07 142.34,63.07
N13135258 on BOTTOM: 95.1,25.48 95.17,25.55 95.17,33.73 95.05,33.86 93.78,33.86 93.65,33.73 93.65,25.76 93.93,25.48
N13135288 on BOTTOM (solid shape): 117.83,19.76 113.79,19.76 113.79,23.98 117.83,23.98
N13135288 on BOTTOM: 115.14,25.98 111.76,25.98 111.05,25.27 111.05,20.14 111.58,19.61 117.91,19.61 117.96,19.66 117.96,24.1 117.63,24.43 115.47,24.43 115.19,24.71 115.19,25.93
N13135380 on BOTTOM: 102.55,19.78 102.55,18.38 101.62,17.45 101.6,17.47 96.95,17.47 96.72,17.7 96.72,19.84 96.9,20.02 100.76,20.02 101.05,20.3 102.06,20.3 102.06,20.27
N13135930 on BOTTOM: 115.82,25.96 115.85,25.96 115.9,26.01 118.08,26.01 118.14,25.96 118.14,25.1 118.08,25.04 115.87,25.04 115.82,25.1
N13193934 on BOTTOM (solid shape): 129.15,32.22 124.33,32.22 124.33,33.49 129.15,33.49
N13193934 on BOTTOM: 122.45,33.5 122.45,32.33 122.66,32.13 125.35,32.13 126.44,31.04 130.91,31.04 130.96,31.09 130.96,32.64 131.67,33.35 133.27,33.35 133.38,33.45 133.38,34.72 133.25,34.85 126.19,34.85 124.92,33.58 122.53,33.58
N13194018 on BOTTOM (solid shape): 118.18,32.19 113.35,32.19 113.35,33.46 118.18,33.46
N13194018 on BOTTOM: 114.15,27.66 115.27,27.66 115.39,27.79 115.39,29.9 117.6,32.11 120.01,32.11 120.07,32.16 120.07,33.38 119.89,33.55 117.45,33.55 116.38,34.62 111.84,34.62 111.58,34.37 111.58,31.12 111.66,31.04 112.95,31.04 114.12,29.87 114.12,27.69

## Text on the board
Ref Des/Silkscreen Bottom: TM | 2529 | RDK-1063 REV B | S/N: | CAPZero-3 | A
Ref Des/Silkscreen Top: RDK-1063 REV B | 2529 | S/N: | L4 | Q9 | Q6 | +
User.16: 7X SLOT/CUTOUT | 5X NON PLATED HOLES | PLEASE DELETE THESE
User.18: M3
User.33: FIGURE | FINISHED_SIZE | 11.811 | 12.0 | 13.78 | 15.0 | 15.748 | 20.0 | 28.0 | 30.0 | 30.98 | 31.0 | 34.0 | 34.02 | 35.429 | 40.0 | 41.0 | 46.0 | 47.24 | 50.0 | 52.012 | 59.0 | 59.02 | 59.059 | 60.0 | 62.0 | 63.0 | 70.0 | 118.11 | 147.642 | 154.02 | 155.98 | 236.22 | 204.72 | 59.059x59.059 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE_DRILL | +3.0/-3.0 | PLATED | NON-PLATED | QTY | 164 | 15 | 1 | 16 | 9 | 119 | 14 | 13 | 18 | 3 | 10 | 28 | 2 | 4 | 22 | 12 | 529 | TOTAL HOLES:
User.34: NOTES: PLEASE DELETE THESE PINS | NOTES: SLOTS AND CUT OUTS
